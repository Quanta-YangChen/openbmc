FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI +=" \
    file://minerva-cmm.cfg \
"
